# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code +hex
  AfterMake: fromelf -cvf .\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\code.axf -o code.txt
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\keil;..\keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: code_def.c code_def.h main.c startup_CMSDK_CM0.s Retarget.c mpuiic.c mpuiic.h ld3320.c pajiic.c lcd.c sflash.c sflash.h pajiic.h paj7620u2_cfg.h lcdfont.h game.c
